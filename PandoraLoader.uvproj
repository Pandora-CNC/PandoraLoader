# Keil uVision project PandoraLoader.uvproj, settings and files
target PandoraLoader_240MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: PandoraLoader_240MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __UPLL_240__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\PandoraLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ./lib/sys/: heap.s stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
    ./lib/nand/: NandDrv.c
    ../../PandoraLoader/: NandLoader.c
    ./: types.h clockcfg.c clockcfg.h config.h hwinfo.c hwinfo.h errors.h main.c mfpga.c mfpga.h
    ./lib/usb/: W55FA93_usbh.lib Usb.h
target PandoraLoader_192MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: PandoraLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\PandoraLoader.scf
  link misc: --entry Reset_Go
target PandoraLoader_192MHz_no_RTC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: PandoraLoader_192MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DISABLE_RTC__ __UPLL_192__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\PandoraLoader.scf
  link misc: --entry Reset_Go
